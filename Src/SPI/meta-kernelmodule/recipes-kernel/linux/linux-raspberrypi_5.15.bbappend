FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-add-ili9341-driver-node-in-dts.patch"

SRC_URI += "file://ili9341_fragment.cfg"

